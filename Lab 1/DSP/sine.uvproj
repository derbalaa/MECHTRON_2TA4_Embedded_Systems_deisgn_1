# Keil uVision project sine.uvproj, settings and files
target ST Link Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sine
  c flags: Optim=1
  c define: ARM_MATH_CM4 __DBG_ITM
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: DirtyFilter.c sine_generator.c low_pass_filter.c Retarget.c
  group Lib-CM4
    ../../../../CMSIS/Lib/ARM/: arm_cortexM4l_math.lib
  group Device-STM32F4
    ./Device/ST/STM32F4/source/: system_stm32f4xx.c Serial_STM32F4.c
    ./: RTX_Conf_STM32F4.c abstract.txt
    ./Device/ST/STM32F4/source/ARM/: startup_stm32f4xx.s
